# Keil uVision project bille.uvproj, settings and files
target Simulation (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TP_GPIO
  AfterMake: "C:\Program Files (x86)\CodeSourcery\Sourcery G++ Lite\bin\arm-none-eabi-size.exe" release\*.elf
  group pilotes
    C:/Keil/stm32lib/stm32f10x/peripherals/src/: stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_rcc.c misc.c stm32f10x_exti.c
  group src
    ./src/: main.c
    ./src/services_applicatives/: galva.c propulseur.c poussoir.c
    ./src/applicatif/: tir.c
    ../pilotes/clock/: clock.c
    ./src/pilotes/: tim.c
  group Boot
    C:/Keil/stm32lib/stm32f10x/boot/stm32f103/: startup-gcc.S
target Reel (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: TP_GPIO
  AfterMake: as above
